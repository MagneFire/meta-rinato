RDEPENDS:pulseaudio-server:append:rinato = " pulseaudio-modules-droid "
