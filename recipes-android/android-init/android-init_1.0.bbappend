FILESEXTRAPATHS:prepend:rinato := "${THISDIR}/${PN}:"
