FILESEXTRAPATHS:prepend:rinato := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:rinato = " file://default.conf"
