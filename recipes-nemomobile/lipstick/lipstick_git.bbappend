RDEPENDS:${PN}:append:rinato = " qt5-qpa-hwcomposer-plugin "
