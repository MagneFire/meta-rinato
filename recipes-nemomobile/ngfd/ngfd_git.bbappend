RDEPENDS:${PN}:append:rinato = " ngfd-plugin-droid-vibrator "
